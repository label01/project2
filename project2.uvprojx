# Keil uVision project project2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Basic\delay;.\Basic\flash;.\Basic\i2c;.\Basic\rtc;.\Basic\sys;.\Basic\usart;.\CMSIS;.\Hardware\BUZZER;.\Hardware\ENCODER;.\Hardware\KEY;.\Hardware\LED;.\Hardware\LM75A;.\Hardware\TM1640;.\Hardware\TOUCH_KEY;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Hardware\OLED0561;.\Basic\bkp;.\Basic\adc;.\Basic\nvic;.\Hardware\DHT11;.\Hardware\MY1690;.\Basic\spi;.\Hardware\CH376
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/flash/: flash.c
    ./Basic/i2c/: i2c.c
    ./Basic/rtc/: rtc.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/bkp/: bkp.c
    ./Basic/adc/: adc.c
    ./Basic/nvic/: nvic.c
    ./Basic/spi/: spi.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group HardWare
    ./Hardware/BUZZER/: buzzer.c
    ./Hardware/ENCODER/: encoder.c
    ./Hardware/KEY/: key.c
    ./Hardware/LED/: led.c
    ./Hardware/LM75A/: lm75a.c
    ./Hardware/TM1640/: tm1640.c
    ./Hardware/TOUCH_KEY/: touch_key.c
    ./Hardware/OLED0561/: oled0561.c
    ./Hardware/DHT11/: dht11.c
    ./Hardware/MY1690/: my1690.c
    ./Hardware/CH376/: ch376.c filesys.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
